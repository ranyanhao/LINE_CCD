# Keil uVision project model.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: model +hex
  c flags: Optim=1
  c define: MK60D10 RAVEN DEBUG
  c misc: --c99
  c include: ..\..\Libraries\drivers\K\src;..\..\Libraries\drivers\K\inc;..\..\Libraries\startup;..\..\Libraries\utilities;..\USER;..\..\Libraries\devices\src;..\..\Libraries\devices\inc;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\startup\CoreSupport
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group USER
    ../USER/: main.c
  group LIB
    ../../Libraries/drivers/K/src/: adc.c can.c common.c cpuidy.c dac.c dma.c enet.c flexbus.c ftm.c gpio.c i2c.c lptmr.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
